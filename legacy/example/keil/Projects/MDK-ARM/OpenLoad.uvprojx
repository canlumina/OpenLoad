# Keil uVision project OpenLoad.uvprojx, settings and files
target OpenLoad (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: OpenLoad +hex
  AfterMake: fromelf  --bin -o ..\..\Output\@L.bin  ..\..\Output\%L
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xE
  c include: ..\..\..\platform\stm32\CMSIS\Device\ST\STM32F1xx\Include;..\..\..\platform\stm32\STM32F1xx_HAL_Driver\Inc;..\..\..\platform\stm32\CMSIS\Include;..\..\User;..\..\Middlewares;..\..\Drivers\BSP;..\..\..\..\middleware\mbedtls\include
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Startup
    ../../../platform/stm32/CMSIS/Device/ST/STM32F1xx/Source/Templates/arm/: startup_stm32f103xe.s
  group User
    ../../User/: main.c stm32f1xx_it.c
    ../../../platform/stm32/CMSIS/Device/ST/STM32F1xx/Source/Templates/: system_stm32f1xx.c
  group App
    ../../Drivers/BSP/: bootloader.c bootloader_cmd.c
  group App/protocol
    ../../Drivers/BSP/: xmodem.c
  group Drivers/BSP
    ../../Drivers/BSP/: bsp_key.c bsp_led.c dma.c gpio.c usart.c spi.c
  group Drivers/flash
    ../../Drivers/BSP/: flash_onchip.c w25q64.c dev_flash.c
  group Drivers/usart
    ../../Drivers/BSP/: dev_usart.c ringbuff.c
  group Midddleware/mbedtls
    ../../../../middleware/mbedtls/library/: aes.c aesni.c arc4.c aria.c asn1parse.c asn1write.c base64.c bignum.c blowfish.c camellia.c ccm.c certs.c chacha20.c chachapoly.c cipher.c cipher_wrap.c cmac.c ctr_drbg.c debug.c des.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c entropy.c entropy_poll.c error.c gcm.c havege.c hkdf.c hmac_drbg.c md.c md2.c md4.c md5.c memory_buffer_alloc.c net_sockets.c nist_kw.c oid.c padlock.c pem.c pk.c pk_wrap.c pkcs5.c pkcs11.c pkcs12.c pkparse.c pkwrite.c platform.c platform_util.c poly1305.c psa_crypto.c psa_crypto_se.c psa_crypto_slot_management.c psa_crypto_storage.c psa_its_file.c ripemd160.c rsa.c rsa_internal.c sha1.c sha256.c sha512.c ssl_cache.c ssl_ciphersuites.c ssl_cli.c ssl_cookie.c ssl_msg.c ssl_srv.c ssl_ticket.c ssl_tls.c threading.c timing.c version.c version_features.c x509.c x509_create.c x509_crl.c x509_crt.c x509_csr.c x509write_crt.c x509write_csr.c xtea.c
  group Drivers/STM32F1xx_HAL_Driver
    ../../../platform/stm32/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_cortex.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_rcc.c stm32f1xx_hal_spi.c stm32f1xx_hal_sram.c stm32f1xx_hal_tim.c stm32f1xx_hal_usart.c stm32f1xx_hal_uart.c stm32f1xx_hal_dma.c stm32f1xx_hal_tim_ex.c stm32f1xx_ll_fsmc.c
