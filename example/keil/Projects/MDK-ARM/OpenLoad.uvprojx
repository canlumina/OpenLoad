# Keil uVision project OpenLoad.uvprojx, settings and files
target OpenLoad (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: OpenLoad +hex
  AfterMake: fromelf  --bin -o ..\..\Output\@L.bin  ..\..\Output\%L
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xE
  c include: ..\..\..\platform\stm32\CMSIS\Device\ST\STM32F1xx\Include;..\..\..\platform\stm32\STM32F1xx_HAL_Driver\Inc;..\..\..\platform\stm32\CMSIS\Include;..\..\User;..\..\Middlewares;..\..\Drivers\SYSTEM\delay;..\..\Drivers\SYSTEM\sys;..\..\Drivers\SYSTEM\usart;..\..\Drivers\BSP
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Startup
    ../../../platform/stm32/CMSIS/Device/ST/STM32F1xx/Source/Templates/arm/: startup_stm32f103xe.s
  group User
    ../../User/: main.c stm32f1xx_it.c
    ../../../platform/stm32/CMSIS/Device/ST/STM32F1xx/Source/Templates/: system_stm32f1xx.c
  group Drivers/STM32F1xx_HAL_Driver
    ../../../platform/stm32/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_cortex.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_rcc.c stm32f1xx_hal_spi.c stm32f1xx_hal_sram.c stm32f1xx_hal_tim.c stm32f1xx_hal_usart.c stm32f1xx_hal_uart.c stm32f1xx_hal_dma.c stm32f1xx_hal_tim_ex.c stm32f1xx_ll_fsmc.c
  group Drivers/BSP
    ../../Drivers/BSP/: bsp_key.c bsp_led.c dma.c gpio.c usart.c spi.c
  group Drivers/flash
    ../../Drivers/BSP/: flash_onchip.c w25q64.c dev_flash.c
  group Drivers/usart
    ../../Drivers/BSP/: dev_usart.c ringbuff.c
